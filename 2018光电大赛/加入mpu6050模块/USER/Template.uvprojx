# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\Drivers;..\FatFS\src;..\USER;..\Applications;..\RmLib;..\Protocol
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group README
    ../: readme.txt
  group Applications
    ../Applications/: include.h init.c init.h key.c key.h led.c led.h schedule.c schedule.h data_transfer.c data_transfer.h Parameter.c Parameter.h rc.c rc.h filter.c filter.h mymath.c mymath.h CanBusTask.c CanBusTask.h superviseTask.c superviseTask.h PID.c PID.h ControlTask.c ControlTask.h Ano_Parameter.c AnoParameter.h Ano_FcData.c Ano_FcData.h task_mode.c task_mode.h
  group Drivers
    ../Drivers/: timer.c timer.h usart.c usart.h drv_w25qxx.c drv_w25qxx.h pwm_in.c pwm_in.h can1.c can1.h spi.c spi.h mpu6050.c mpu6050.h
  group FatFs
    ../FatFS/src/: diskio.c ff.c
  group RmLib
    ../RmLib/: common.h fifo.h LostCounter.h pid_regulator.h ramp.h
  group Protocol
    ../Protocol/: MF_CRC16.h protocal.h
