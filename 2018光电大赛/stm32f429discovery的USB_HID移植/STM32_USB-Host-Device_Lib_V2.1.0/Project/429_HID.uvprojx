# Keil uVision project 429_HID.uvprojx, settings and files
target HID (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 429_HID
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c include: ..\CMSIS;..\STM32_USB_Device_Library\inc;..\STM32_USB_OTG_Driver\inc;..\STM32F4xx_StdPeriph_Driver\inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f4xx.s
  group USER
    ../USER/: app.c stm32fxxx_it.c usb_bsp.c usbd_desc.c usbd_usr.c
  group USB_Driver
    ../STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Device
    ../STM32_USB_Device_Library/src/: usbd_core.c usbd_hid_core.c usbd_ioreq.c usbd_req.c
  group FWLIB
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c
